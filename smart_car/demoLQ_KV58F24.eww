<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\demoLQ_KV58F24.ewp</path>
  </project>
</workspace>


